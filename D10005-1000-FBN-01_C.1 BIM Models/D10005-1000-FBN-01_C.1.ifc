Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2026-04-08T16:15:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 08 16:15:59 2026 * Host: Yoga * Database: D:\Temp\fc611c4b-5023-439d-9981-df5257fdc4ad\524b0705-43b3-47c7-a99e-6f012d383984\ifc * Database version: 5507 * Database creation date: Wed Apr 08 16:15:56 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 08 16:15:56 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 08 16:15:56 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum

# IfcFlowController: DB3100:DB3100, DB3100:DB3100:1094435
In: Level 0
Type - PredefinedType: MIXING; Material: Default
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_78:Shower manual water supply sets; CodePerformance: WRAS_TMV2; Color: Various; Constituents: n/a; Description: ShowerValveAndTwoWayDiverter; DurationUnit: year; ExpectedLife: n/a; Features: DB3100_Lever_DB3101_Leverless; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel_.5/PowderCoated_.6/CeramicCoated; Grade: Various_316SS; IfcExportAs: IfcValveType; IfcExportType: MIXING; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Valve/Brass_FacePlate/StainlessSteel; ModelNumber: DB3100/DB3101; ModelReference: DolphinSolutionsLimited_ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter; Name: ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter_DB3100_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 215 mm; NominalLength: 45 mm; NominalWidth: 130 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-shower-valve/; ReplacementCost: n/a; Shape: Rectangular; Size: 130x215x45; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3100; Uniclass2015Code: Pr_40_20_87_78; Uniclass2015Title: Shower manual water supply sets; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 5; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Materials and Finishes - Primary Material: Default; Secondary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: DB3100
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter_DB3100_DolphinSolutionsLimited; Category: Pr_40_20_87_78:Shower manual water supply sets
Pset_DistributionFlowElementCommon - Reference: DB3100:DB3100; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 750 mm; Host: Level : Level 0; Offset from Host: 750 mm
Dimensions - Area: 0.0423619 m2; Volume: 0.000242714 m3
Identity Data - Mark: 719
Other - Family: DB3100: DB3100; Family and Type: DB3100: DB3100; Type: DB3100: DB3100; Type Id: DB3100: DB3100
Phasing - Phase Created: New Construction

# IfcFlowTerminal: AL0220:AL0220, AL0220:AL0220:1094484
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: AL0220
Type - Other - Category: Plumbing Fixtures; Family Name: AL0220
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: AL0220:AL0220; sets with these values: 2
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 719.978 mm; Host: Level : Level 0; Offset from Host: 719.978 mm
Dimensions - Area: 0.00000628277 m2; Volume: 3.1402e-09 m3
Identity Data - Mark: 768
Other - Family: AL0220: AL0220; Family and Type: AL0220: AL0220; Type: AL0220: AL0220; Type Id: AL0220: AL0220
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC2008:BC2008 Dolphin Slimline Eco Hand Dryer, BC2008:BC2008 Dolphin Slimline Eco Hand Dryer:356950
In: Level 0
Type - Classification: D2010900 Other Plumbing Fixtures (Uniformat); Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 101 mm; Height: 270.2 mm; Width: 161.4 mm
Type - Identity Data - AccessibilityPerformance: n/a; Assembly Code: D2010900; Assembly Description: Other Plumbing Fixtures; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; BodyIngressProtectionMinimum: IP24; Category: Pr_40_70_62_37:Hand dryers; CodePerformance: n/a; Color: Brushed satin/ White_BC2008W/PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; DurationUnit: year; ElectricalSupplyFrequency: 50/ 60 Hz; ElectricalSupplyPowerRating: 500-900 W; ElectricalSupplyRatedOperationalVoltage: 220-240 V a.c; ExpectedLife: n/a; Features: Touch free; Finish: BrushedSatin Suffix_-PVD_-PCPowderCoated_-CCCeramicCoated; Form: High-velocity air; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: Dolphin Solutions Limited; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: n/a; Model: BC2008; ModelNumber: BC2008/ BC2008W; ModelReference: DolphinSolutionsLimited_VelocityMiniHandDryer; Name: HandDryers_VelocityMiniHandDryer_BC2008_DolphinSolutionsLimited; NBSDescription: Hand dryers; NBSReference: 45-35-72/334; NBSTypeID: n/a; NoiseLevelAt1MMaximum: 76.6 dB(A); NominalHeight: 270; NominalLength: 101; NominalWidth: 162; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.14; Operation: Automatic; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-mini-hand-dryer-bc2008/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 162 x 270 x 101 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC2008 Dolphin Slimline Eco Hand Dryer; Uniclass2015Code: Pr_40_70_62_37; Uniclass2015Title: Hand dryers; URL: www.dolphinsolutios.co.uk; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC2008
Type - Pset_ElementShading - Color: Brushed satin/ White_BC2008W/PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_VelocityMiniHandDryer; Manufacturer: Dolphin Solutions Limited
Type - Pset_ProductRequirements - Name: HandDryers_VelocityMiniHandDryer_BC2008_DolphinSolutionsLimited; Category: Pr_40_70_62_37:Hand dryers
Pset_DistributionFlowElementCommon - Reference: BC2008:BC2008 Dolphin Slimline Eco Hand Dryer; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 800 mm; Host: Level : Level 0; Offset from Host: 800 mm
Dimensions - Area: 0.0910884 m2; Volume: 0.0043877 m3
Identity Data - Mark: 10
Other - Family: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer; Family and Type: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer; Type: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer; Type Id: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC238SS:BC238SS, BC238SS:BC238SS:1094433
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 103.5 mm; Height: 286 mm; Width: 125 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Capacity: 1000 ml; Category: Pr_40_70_22_81:Soap dispensers; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Wall mounted soap or sanitiser dispenser; DurationUnit: year; ElectricalSupplyPowerRating: 4 x C cell batteries; ElectricalSupplyRatedOperationalVoltage: Optional3VMainSupply; ExpectedLife: n/a; Features: TouchFree_Liquid_or_Sanitiser_Cartridge; Finish: BrushedSatin Suffix_-PVD_-PCPowderCoated_-CCCeramicCoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC238SS; ModelReference: DolphinSolutionsLimited_WallMountedTouchFreeLiquidSoapSanitiserDispenser; Name: SoapDispensers_TouchFree_SoapSanitiserDispenser_BC238SS_DolphinSolutionsLimited; NBSDescription: Soap dispensers; NBSReference: 45-35-72/358; NBSTypeID: n/a; NominalHeight: 268; NominalLength: 104; NominalWidth: 125; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.34; Operation: Automatic; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-auto-soap-sanitiser-dispenser/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 125 x 268 x 104 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC238SS; Uniclass2015Code: Pr_40_70_22_81; Uniclass2015Title: Soap dispensers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC238SS
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WallMountedTouchFreeLiquidSoapSanitiserDispenser; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: SoapDispensers_TouchFree_SoapSanitiserDispenser_BC238SS_DolphinSolutionsLimited; Category: Pr_40_70_22_81:Soap dispensers
Pset_DistributionFlowElementCommon - Reference: BC238SS:BC238SS; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 800 mm; Host: Level : Level 0; Offset from Host: 800 mm
Dimensions - Area: 0.0782756 m2; Volume: 0.00369491 m3
Identity Data - Mark: 717
Other - Family: BC238SS: BC238SS; Family and Type: BC238SS: BC238SS; Type: BC238SS: BC238SS; Type Id: BC238SS: BC238SS
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC4302:BC4302, BC4302:BC4302:356951
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Width: 145.5 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_88:Toilet roll holders; CodePerformance: n/a; Color: Brushed Satin/ BC4302B_Polished; Constituents: n/a; Description: Toilet tissue dispenser; DurationUnit: year; ExpectedLife: n/a; Features: Bulk Pack Tissue; Finish: Brushed Satin/ Polished_BC4302B; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC4302/BC4302B; ModelReference: DolphinSolutionsLimited_ToiletTissueDispenser; Name: ToiletTissueDispenser_BulkPack_BC4302_DolphinSolutionsLimited; NBSDescription: Toilet roll holders; NBSReference: 45-35-72/366; NBSTypeID: n/a; NominalHeight: 240 mm; NominalLength: 111 mm; NominalWidth: 145 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.21; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-toilet-tissue-dispenser-bc4302/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 145 x 240 x 111 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC4302; Uniclass2015Code: Pr_40_20_76_88; Uniclass2015Title: Toilet roll holders; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC4302
Type - Pset_ElementShading - Color: Brushed Satin/ BC4302B_Polished
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ToiletTissueDispenser; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ToiletTissueDispenser_BulkPack_BC4302_DolphinSolutionsLimited; Category: Pr_40_20_76_88:Toilet roll holders
Pset_DistributionFlowElementCommon - Reference: BC4302:BC4302; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 800 mm; Host: Level : Level 0; Offset from Host: 800 mm
Dimensions - Area: 0.0829836 m2; Volume: 0.00350184 m3
Identity Data - Mark: 11
Other - Family: BC4302: BC4302; Family and Type: BC4302: BC4302; Type: BC4302: BC4302; Type Id: BC4302: BC4302
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5023-07SS:Standard (3)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 800 mm; Height: 140 mm; Width: 100 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182_DocM_BS8300; Color: Brushed Satin Polished-PSS; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: 800mm Fold Down; Finish: Brushed Satin/ Polished-PSS; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5023-07SS/BC5023-07-PSS; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_800mmFoldDown32mmGrabRail_BC5023-07SS_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 139 mm; NominalLength: 800 mm; NominalWidth: 100 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-contemporary-grab-rail/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 800 x 100 x 139 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5023-07SS
Type - Pset_ElementShading - Color: Brushed Satin Polished-PSS
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail
Type - Pset_ProductRequirements - Name: SupportRails_800mmFoldDown32mmGrabRail_BC5023-07SS_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Pset_DistributionFlowElementCommon - Reference: BC5023-07SS:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no
Dimensions - Area: 0.0683182 m2; Volume: 0.000693445 m3
Other - Family: BC5023-07SS: Standard; Family and Type: BC5023-07SS: Standard; Type: BC5023-07SS: Standard; Type Id: BC5023-07SS: Standard
Phasing - Phase Created: New Construction
Name (BC5023-07SS:Standard:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
356942 | 498.5 | 2
1094472 | 566.285 | 756
1094473 | 566.285 | 757

# IfcFlowTerminal: BC5083-02:Standard (7)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Depth: 76 mm; Diameter: 32 mm; Width: 600 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182; Color: Brushed Satin; Constituents: n/a; Description: 600mm long 32mm Grab Rail 75mm Rosettes; DurationUnit: year; ExpectedLife: n/a; Features: 50mm wall clearance; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-02; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_32mmGrabRail_BC5083-02_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 82 mm; NominalLength: 600 mm; NominalWidth: 32 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-grab-rail-2/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 600 x 32 x 82 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-02
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: SupportRails_32mmGrabRail_BC5083-02_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Pset_DistributionFlowElementCommon - Reference: BC5083-02:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.0760405 m2; Volume: 0.000185759 m3
Other - Family: BC5083-02: Standard; Family and Type: BC5083-02: Standard; Type: BC5083-02: Standard; Type Id: BC5083-02: Standard
Phasing - Phase Created: New Construction
Name (BC5083-02:Standard:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
356943 | 1100 | 3
356945 | 1100 | 5
356946 | 1100 | 6
356947 | 664 | 7
1094475 | 1100 | 759
1094476 | 664 | 760
1094477 | 664 | 761

# IfcFlowTerminal: BC5083-07:BC5083-07-BLK, BC5083-07:BC5083-07-BLK:1094430
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 274 mm; Height: 160 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_98:WCPanBackRests; CodePerformance: DocM_BS8300; Color: WhiteAndBrushedSatin; Constituents: n/a; Description: Brushed Satin back rest and white pad; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlesSteel_ClosedCellPolyurathane; ModelNumber: BC5083-07; ModelReference: DolphinSolutionsLimited_WhiteBackRestPad; Name: WCPanBackRests_BackRest_WhiteBackRestPad_BC5083-07_DolphinSolutionsLimited; NBSDescription: WC Pan Back Rests; NBSReference: 45-35-72/382; NBSTypeID: n/a; NominalHeight: 160 mm; NominalLength: 395 mm; NominalWidth: 270 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-padded-backrest/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 395 x 160 x 270 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-07-BLK; Uniclass2015Code: Pr_40_20_76_98; Uniclass2015Title: WC Pan Back Rests; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-07
Type - Pset_ElementShading - Color: WhiteAndBrushedSatin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WhiteBackRestPad; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WCPanBackRests_BackRest_WhiteBackRestPad_BC5083-07_DolphinSolutionsLimited; Category: Pr_40_20_76_98:WCPanBackRests
Pset_DistributionFlowElementCommon - Reference: BC5083-07:BC5083-07-BLK; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 664 mm; Host: Level : Level 0; Offset from Host: 664 mm
Dimensions - Area: 0.118583 m2; Volume: 0.00330378 m3
Identity Data - Mark: 714
Other - Family: BC5083-07: BC5083-07-BLK; Family and Type: BC5083-07: BC5083-07-BLK; Type: BC5083-07: BC5083-07-BLK; Type Id: BC5083-07: BC5083-07-BLK
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-101:Standard, BC5083-101:Standard:356953
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 10 mm; Height: 1000 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_25_71_53_06:Bathroom mirrors; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Form: Wall-mounted; Grade: n/a; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Glass; ModelNumber: BC5083-101; ModelReference: DolphinSolutionsLimited_Mirror; Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; NBSDescription: Bathroom mirrors; NBSReference: 45-35-72/336; NBSTypeID: n/a; NominalHeight: 1000; NominalLength: 15; NominalWidth: 400; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.95.17.17; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 400 x 1000 x 15 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_25_71_53_06; Uniclass2015Title: Bathroom mirrors; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-101
Type - Pset_ElementShading - Color: n/a
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Mirror
Type - Pset_ProductRequirements - Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; Category: Pr_25_71_53_06:Bathroom mirrors
Pset_DistributionFlowElementCommon - Reference: BC5083-101:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 600 mm; Host: Level : Level 0; Offset from Host: 600 mm
Dimensions - Area: 0.827875 m2; Volume: 0.004 m3
Identity Data - Mark: 13
Other - Family: BC5083-101: Standard; Family and Type: BC5083-101: Standard; Type: BC5083-101: Standard; Type Id: BC5083-101: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-121:Standard (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 2500 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits; CodePerformance: BS8300:DocM; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: BS8300:DocM_PullCord_OpenDoorIndicator_ResetButton; Finish: Brushed Satin; Form: Surface-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-121; ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit; Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; NBSDescription: AssistanceCallPulCordUnits; NBSReference: 90-70-05/320; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 0; NominalWidth: 0; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.85.30.24.11; Operation: PullCord; ProductInformation: https://www.nationalbimlibrary.com/en-gb/vox-ignis-limited/vilx-cpp-assist-call-pull-cord-plate/?lo=en-GB; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_75_75_04_04; Uniclass2015Title: AssistanceCallPulCordUnits; Uniclass2015Version: Products v1.15; Version: 1; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-121
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit
Type - Pset_ProductRequirements - Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits
Pset_DistributionFlowElementCommon - Reference: BC5083-121:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Offset from Host: 0 mm; Host: Level : Level 0
Dimensions - Area: 0.0221672 m2; Volume: 0.000127718 m3
Other - Family: BC5083-121: Standard; Family and Type: BC5083-121: Standard; Type: BC5083-121: Standard; Type Id: BC5083-121: Standard
Phasing - Phase Created: New Construction
Name (BC5083-121:Standard:...) | Mark
356952 | 12
1094474 | 758

# IfcFlowTerminal: BC725:BC725 (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_15:Clothes hooks; CodePerformance: n/a; Color: Brushed Satin or RALPowderCoated; Constituents: n/a; Description: Clothes hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin or RALPowderCoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC725/BC725PC; ModelReference: DolphinSolutionsLimited_ClothesHooks; Name: Clothes hooks_BC725_DolphinSolutionsLimited; NBSDescription: Clothes hooks; NBSReference: 45-35-72/322; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 60; NominalWidth: 48; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.31; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/single-robe-hook-bc725/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 60 x 48 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC725; Uniclass2015Code: Pr_40_30_78_15; Uniclass2015Title: Clothes hooks; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC725
Type - Pset_ElementShading - Color: Brushed Satin or RALPowderCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ClothesHooks; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Clothes hooks_BC725_DolphinSolutionsLimited; Category: Pr_40_30_78_15:Clothes hooks
Pset_DistributionFlowElementCommon - Reference: BC725:BC725; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.00466682 m2; Volume: 0.0000330174 m3
Other - Family: BC725: BC725; Family and Type: BC725: BC725; Type: BC725: BC725; Type Id: BC725: BC725
Phasing - Phase Created: New Construction
Name (BC725:BC725:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
356954 | 1050 | 14
356955 | 1400 | 15

# IfcFlowTerminal: BC727:BC727, BC727:BC727:1094385
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 133 mm; Height: 391 mm; Width: 88 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_86:Toilet brush holders; CodePerformance: n/a; Color: Brush Satin or RALPowdercoated; Constituents: n/a; Description: Toilet brush holder; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brush Satin or RALPowdercoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC727/BC727PC; ModelReference: DolphinSolutionsLimited_ToiletBrushHolder; Name: ToiletBrushHolder_BC727_DolphinSolutionsLimited; NBSDescription: Toilet brush holders; NBSReference: 45-35-72/364; NBSTypeID: n/a; NominalHeight: 391; NominalLength: 133; NominalWidth: 88; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-toilet-brush-set-bc727/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 88 x 391 x 133 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC727; Uniclass2015Code: Pr_40_20_76_86; Uniclass2015Title: Toilet brush holders; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC727
Type - Pset_ElementShading - Color: Brush Satin or RALPowdercoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ToiletBrushHolder; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ToiletBrushHolder_BC727_DolphinSolutionsLimited; Category: Pr_40_20_76_86:Toilet brush holders
Pset_DistributionFlowElementCommon - Reference: BC727:BC727; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 100 mm; Host: Level : Level 0; Offset from Host: 100 mm
Dimensions - Area: 0.0857889 m2; Volume: 0.000302901 m3
Identity Data - Mark: 669
Other - Family: BC727: BC727; Family and Type: BC727: BC727; Type: BC727: BC727; Type Id: BC727: BC727
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC751:BC751, BC751:BC751:1094429
In: Level 0
Type - Material: Default
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 170 mm; Height: 50 mm; Width: 250 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_06:BathroomShelves; CodePerformance: n/a; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC751; ModelReference: DolphinSolutionsLimited_ColostomyShelf; Name: BathroomShelves_ColostomyShelf_BC751_DolphinSolutionsLimited; NBSDescription: BathroomShelves; NBSReference: 45-35-72/354; NBSTypeID: n/a; NominalHeight: 50; NominalLength: 250; NominalWidth: 150; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.11; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-shelf-bc751/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 150 x 250 x 50 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC751; Uniclass2015Code: Pr_40_30_78_06; Uniclass2015Title: BathroomShelves; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Materials and Finishes - Primary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: BC751
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ColostomyShelf
Type - Pset_ProductRequirements - Name: BathroomShelves_ColostomyShelf_BC751_DolphinSolutionsLimited; Category: Pr_40_30_78_06:BathroomShelves
Pset_DistributionFlowElementCommon - Reference: BC751:BC751; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 900 mm; Host: Level : Level 0; Offset from Host: 900 mm
Dimensions - Area: 0.0682907 m2; Volume: 0.000134839 m3
Identity Data - Mark: 713
Other - Family: BC751: BC751; Family and Type: BC751: BC751; Type: BC751: BC751; Type Id: BC751: BC751
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC951:BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin, BC951:BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin:356949
In: Level 0
Type - Material: Default (6)
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 170 mm; Height: 542 mm; Width: 282 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Capacity: 24 litres; Category: Pr_40_50_07_96:WasteBins; CodePerformance: n/a; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Plastic liner; Finish: Brushed Satin; Form: WallOrFloorMounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC951; ModelReference: DolphinSolutionsLimited_FloorStandingOrWallMountedWasteBin; Name: WasteBins_FloorStandingOrWallMountedWasteBin_BC951_DolphinSolutionsLimited; NBSDescription: Waste bins; NBSReference: 45-35-72/380; NBSTypeID: n/a; NominalHeight: 542; NominalLength: 170; NominalWidth: 282; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.31.11; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-free-standing-surface-mounted-bin/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 282 x 542 x 170 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Uniclass2015Code: Pr_40_50_07_96; Uniclass2015Title: Waste bins; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Materials and Finishes - Primary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: BC951
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_FloorStandingOrWallMountedWasteBin
Type - Pset_ProductRequirements - Name: WasteBins_FloorStandingOrWallMountedWasteBin_BC951_DolphinSolutionsLimited; Category: Pr_40_50_07_96:WasteBins
Pset_DistributionFlowElementCommon - Reference: BC951:BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Host: Level : Level 0; Offset from Host: 0 mm
Dimensions - Area: 0.535081 m2; Volume: 0.000583357 m3
Identity Data - Mark: 9
Other - Family: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Family and Type: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Type: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Type Id: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC958:BC958, BC958:BC958:1094414
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 103 mm; Height: 369 mm; Width: 281.5 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_70_22_62:Paper towel dispensers; CodePerformance: n/a; Color: Brushed Satin; Constituents: n/a; Description: Paper towel dispenser; DurationUnit: year; ExpectedLife: n/a; Features: Locakble; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlesSteel; ModelNumber: BC958; ModelReference: DolphinSolutionsLimited_PaperTowelDispenser; Name: PaperTowelDispensers_Prestige_PaperTowelDispenser_BC958_DolphinSolutionsLimited; NBSDescription: Paper towel dispensers; NBSReference: 45-35-72/344; NBSTypeID: n/a; NominalHeight: 369; NominalLength: 103; NominalWidth: 282; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.17; Operation: Pull-out; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-paper-towel-dispenser-bc958/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 282 x 369 x 103 mm; SustainabilityPerformance: n/a; TagNumber: n/a; TowelCapacity: 400; Type Name: BC958; Uniclass2015Code: Pr_40_70_22_62; Uniclass2015Title: Paper towel dispensers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC958
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_PaperTowelDispenser; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: PaperTowelDispensers_Prestige_PaperTowelDispenser_BC958_DolphinSolutionsLimited; Category: Pr_40_70_22_62:Paper towel dispensers
Pset_DistributionFlowElementCommon - Reference: BC958:BC958; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Offset from Host: 0 mm; Host: Level : Level 0
Dimensions - Area: 0.176441 m2; Volume: 0.01063 m3
Identity Data - Mark: 698
Other - Family: BC958: BC958; Family and Type: BC958: BC958; Type: BC958: BC958; Type Id: BC958: BC958
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3001:DB3001, DB3001:DB3001:1094436
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_76:Shower heads; CodePerformance: WRAS; Color: Various; Constituents: n/a; Description: UltraThinRoundShowerHead; DurationUnit: year; ExpectedLife: n/a; Features: 88Nozzles_6&9LitreFlowRegulators; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel_.5/PowderCoated_.6/CeramicCoated; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3001; ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3001; Name: ShowerHeads_WRAS_DB3001_UltraThinRoundShowerHead_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 44 mm; NominalWidth: 250 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-round-shower-head/; ReplacementCost: n/a; Shape: Rectangular; Size: 250x44; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3001; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Title: Shower heads; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3001
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3001; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerHeads_WRAS_DB3001_UltraThinRoundShowerHead_DolphinSolutionsLimited; Category: Pr_40_20_87_76:Shower heads
Type - Pset_SanitaryTerminalTypeShower - Color: Various
Pset_DistributionFlowElementCommon - Reference: DB3001:DB3001; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2250 mm; Host: Level : Level 0; Offset from Host: 2250 mm
Dimensions - Area: 0.0518063 m2; Volume: 0.000245526 m3
Identity Data - Mark: 720
Other - Family: DB3001: DB3001; Family and Type: DB3001: DB3001; Type: DB3001: DB3001; Type Id: DB3001: DB3001
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3020:DB3020, DB3020:DB3020:1094440
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_76:Shower heads; CodePerformance: WRAS; Color: BrushedSatin/MirrorPolished; Constituents: n/a; Description: HandHeldShowerHead; DurationUnit: year; ExpectedLife: n/a; Features: 6&9LitreFlowRegulators; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3020; ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3020; Name: ShowerHeads_WRAS_DB3020_HandHeldShowerHead_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 185 mm; NominalWidth: 23 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-hand-held-shower-head/; ReplacementCost: n/a; Size: 185x23; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3020; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Title: Shower heads; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3020
Type - Pset_ElementShading - Color: BrushedSatin/MirrorPolished
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3020; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerHeads_WRAS_DB3020_HandHeldShowerHead_DolphinSolutionsLimited; Category: Pr_40_20_87_76:Shower heads
Type - Pset_SanitaryTerminalTypeShower - Color: BrushedSatin/MirrorPolished
Pset_DistributionFlowElementCommon - Reference: DB3020:DB3020; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 1220 mm; Host: Level : Level 0; Offset from Host: 1220 mm
Dimensions - Area: 0.00832223 m2; Volume: 0.0000782395 m3
Identity Data - Mark: 724
Other - Family: DB3020: DB3020; Family and Type: DB3020: DB3020; Type: DB3020: DB3020; Type Id: DB3020: DB3020
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3041.150:DB3041.150, DB3041.150:DB3041.150:1094439
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Brushed Satin; Constituents: n/a; Description: Shower hose; DurationUnit: year; ExpectedLife: n/a; Features: "1/2""BSP_connection_SS316"; Finish: Brushed Satin; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3041; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3041_ShowerHose; Name: ShowerFittingsPackage_WRAS_DB3041_ShowerHose_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalLength: 1500 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-shower-hose/; ReplacementCost: n/a; Size: 1500 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3041.150; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3041.150
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3041_ShowerHose; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_DB3041_ShowerHose_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Type - Pset_SanitaryTerminalTypeShower - Color: Brushed Satin
Pset_DistributionFlowElementCommon - Reference: DB3041.150:DB3041.150; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 1220 mm; Host: Level : Level 0; Offset from Host: 1220 mm
Dimensions - Area: 0.0173889 m2; Volume: 0.000129094 m3
Identity Data - Mark: 723
Other - Family: DB3041.150: DB3041.150; Family and Type: DB3041.150: DB3041.150; Type: DB3041.150: DB3041.150; Type Id: DB3041.150: DB3041.150
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3061.350:DB3061.350, DB3061.350:DB3061.350:1094437
In: Level 0
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 350 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: BrushedSatin/MirrorPolished; Constituents: n/a; Description: Shower arm; DurationUnit: year; ExpectedLife: n/a; Features: Available in 4 lengths; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass; ModelNumber: DB3061.300/DB3061.350/DB3061.400/DB3061.450; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3061; Name: ShowerFittingsPackage_WRAS_DB3061_ShowerArm_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 0; NominalLength: 215 mm; NominalWidth: 0; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-shower-arm-2/; ReplacementCost: n/a; Shape: n/a; Size: 215 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3061.350; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: 2; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3061.350
Type - Pset_ElementShading - Color: BrushedSatin/MirrorPolished
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3061; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_DB3061_ShowerArm_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Pset_DistributionFlowElementCommon - Reference: DB3061.350:DB3061.350; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2350 mm; Host: Level : Level 0; Offset from Host: 2350 mm
Dimensions - Area: 0.0165068 m2; Volume: 0.000155136 m3
Identity Data - Mark: 721
Other - Family: DB3061.350: DB3061.350; Family and Type: DB3061.350: DB3061.350; Type: DB3061.350: DB3061.350; Type Id: DB3061.350: DB3061.350
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3073:Family1, DB3073:Family1:1094438
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Various; Constituents: n/a; Description: Shower wall outlet and holder; DurationUnit: year; ExpectedLife: n/a; Features: "1/2""BSP_connection"; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel_.5/PowderCoated_.6/CeramicCoated; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3073; ModelReference: ShowerFittingsPackages_DolphinSolutionsLimited_WRAS_DB3073; Name: ShowerFittingsPackages_WRAS_DB3073_ShowerWallOutletAndHolder_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 31 mm; NominalWidth: 68 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-shower-wall-outlet-and-holder-2/; ReplacementCost: n/a; Size: 31x68 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Family1; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3073
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackages_DolphinSolutionsLimited_WRAS_DB3073; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackages_WRAS_DB3073_ShowerWallOutletAndHolder_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Type - Pset_SanitaryTerminalTypeShower - Color: Various
Pset_DistributionFlowElementCommon - Reference: DB3073:Family1; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 920 mm; Host: Level : Level 0; Offset from Host: 920 mm
Dimensions - Area: 0.00716927 m2; Volume: 0.0000498867 m3
Identity Data - Mark: 722
Other - Family: DB3073: Family1; Family and Type: DB3073: Family1; Type: DB3073: Family1; Type Id: DB3073: Family1
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3090.450:DB3090.450, DB3090.450:DB3090.450:1094441
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Brushed Satin; Constituents: n/a; Description: Shower slider rail and holder; DurationUnit: year; ExpectedLife: n/a; Finish: Brushed Satin; Grade: CZ121; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass; ModelNumber: DB3090.450; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3090.450_ShowerSliderRailAndHolder; Name: ShowerFittingsPackage_WRAS_DB3090.450_ShowerSliderRailAndHolder_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 79 mm; NominalLength: 450mm; NominalWidth: 18 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-450mm-shower-slider-rail-and-holder/; ReplacementCost: n/a; Size: 18x450x79 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3090.450; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3090.450
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a
